# IAR project UHF-test.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.CCDiagSuppress: Pe111 , Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Users\Administrator\Desktop\UHF-TEST\inc
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: ht1621.c key.c led.c main.c
